# Keil uVision project Droidbot_SW_v3.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Droidbot_SW_v3 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RA1
  c include: .\modules\pwm_handler;.\modules\compile_switches;.\modules\motion_handler;..\TivaWare_C_Series-2.1.1.71;.\modules\interrupt_handler;.\modules\comparator_handler;.\modules\gpio_handler;.\modules\timer_handler;.\modules\cyclic_activity_handler;.\modules\lcd_handler;.\3rd_pty_drv;.\modules\custom_types;.\modules\printing_handler;.\modules\ssi_handler;.\modules\system_handler;.\modules\resources;.\modules\adc_handler;.\modules\accelerometer_handler;.\modules\i2c_handler;.\modules\shift_register_handler;.\OS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group startup_source
    ./: startup_new.s
  group main
    ./: main.c
  group modules
    ./modules/adc_handler/: adc_handler.c
    ./modules/comparator_handler/: comparator_handler.c
    ./modules/cyclic_activity_handler/: cyclic_activity_handler.c
    ./modules/gpio_handler/: gpio_handler.c
    ./modules/interrupt_handler/: interrupt_handler.c
    ./modules/lcd_handler/: lcd_handler.c
    ./modules/motion_handler/: motion_handler.c
    ./modules/printing_handler/: printing_handler.c
    ./modules/pwm_handler/: pwm_handler.c
    ./modules/ssi_handler/: ssi_handler.c
    ./modules/system_handler/: system_handler.c
    ./modules/timer_handler/: timer_handler.c
    ./modules/i2c_handler/: i2c_handler.c
    ./modules/accelerometer_handler/: accelerometer_handler.c
    ./modules/shift_register_handler/: shift_register_handler.c
  group driverlib
    ../TivaWare_C_Series-2.1.1.71/driverlib/rvmdk/: driverlib.lib
  group 3rd party drivers
    ./3rd_pty_drv/: UART.c BSP_TM4C.c
  group Configs_Types_Resorces
    ./modules/custom_types/: custom_types.h
    ./modules/resources/: resources.h
    ./modules/compile_switches/: compile_switches.h
  group OS
    ./OS/: os_core.c os_hw.c osasm.s
